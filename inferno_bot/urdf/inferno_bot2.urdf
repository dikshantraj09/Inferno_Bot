Commit message: Add files via upload

File: inferno_bot/urdf/inferno_bot2.urdf (robot description, URDF)
Before this commit: robot inferno_bot, 10 links, 9 joints
Joints:
- joint jlidar: origin xyz=0.10599 -0.16721 0.29424 rpy=0 3.14 -1.57 -> xyz=0.10599 -0.16721 0.29424 rpy=-1.5708 0 -1.5708
